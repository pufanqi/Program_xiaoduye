# Keil uVision project NaClO.uvprojx, settings and files
target STM32F103RET6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NaClO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Library\CMISIS;.\Library\StdPeriph_Driver\inc;.\Users\App;.\Users\Module
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./Users/App/: main.c stm32f10x_it.c test.c production.c schedule.c client.c
  group Module
    ./Users/Module/: CO2_flux.c stepping_motor.c water_flux.c approach_switch.c relay.c stoste.c cardreader.c screen.c gprs.c timer.c delay.c pvd_flash.c
  group CMISIS
    ./Library/CMISIS/: system_stm32f10x.c stm32f10x.h core_cm3.c
  group StdPeripher_Driver
    ./Library/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_pwr.c
  group MDK
    ./Library/: startup_stm32f10x_hd.s
